# Keil uVision project snake51.uvproj, settings and files
target SNAKE51 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: snake51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USER;.\BSP\LED
  group STARTUP
    ./: STARTUP.A51
  group USER
    ./USER/: main.c
  group BSP
    ./BSP/LED/: led.c led.h
